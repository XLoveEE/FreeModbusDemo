# Keil uVision project ModbusDemo.uvprojx, settings and files
target ModbusDemo (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ModbusDemo +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: .\Fwlib\inc;.\Fwlib\src;.\modbus\ascii;.\modbus\functions;.\modbus\include;.\modbus\rtu;.\modbus\tcp;.\port;.\USER;.\W5500;.\SYS;.\USART
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./modbus/: mb.c
    ./USER/: main.c stm32f10x.h stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h system_stm32f10x.h
  group FWLIB
    ./Fwlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group MD_ASCII
    ./modbus/ascii/: mbascii.c
  group MD_FUNCTIONS
    ./modbus/functions/: mbfunccoils.c mbfuncdiag.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbutils.c
  group MD_INCLUDE
    ./modbus/include/: mb.h mbconfig.h mbframe.h mbfunc.h mbport.h mbproto.h mbutils.h
  group MD_RTU
    ./modbus/rtu/: mbcrc.c mbcrc.h mbrtu.c mbrtu.h
  group MD_TCP
    ./modbus/tcp/: mbtcp.c mbtcp.h
  group MD_PORTS
    ./port/: portevent.c porttimer.c port.h porttcp.c portserial.c
  group W5500
    ./W5500/: W5500.c w5500.h
  group SYS
    ./SYS/: sys.c
  group USART
    ./USART/: usart.c
software components: CMSIS:CORE 4.3.0, Device:Startup 1.0.0
